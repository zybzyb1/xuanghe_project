# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.3
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ADC_TempSensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F002xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc\user
  library: MicroLIB
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f002xx.s
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
    ../Src/user/: areaFill2.c infrared.c touch.c user_gpio.c buzzer.c encryptionDecryption.c user_flash.c
  group BSP/py32f002xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F002xx_Start_Kit/: py32f002xx_Start_Kit.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_usart.c py32f0xx_hal_exti.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_iwdg.c py32f0xx_hal_flash.c
    ../../../../../../drivers/PY32F0xx_HAL_Driver/src/: py32f0xx_hal_rcc.c py32f0xx_hal_gpio.c py32f0xx_hal_pwr.c py32f0xx_hal_uart.c py32f0xx_hal_cortex.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
