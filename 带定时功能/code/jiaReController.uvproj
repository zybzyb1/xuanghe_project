# Keil uVision project jiaReController.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: jiaReController +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\Driver\inc
  group asm
    ./: STARTUP.A51
    ./src/: fixcode.asm
  group inc
    ./src/: stc8g1k_code.h uart.h
  group src
    ./src/: stc8g1k_code.c uart.c
  group driver
    ./Driver/src/: STC8G_H_GPIO.c STC8G_H_Timer.c STC8G_H_WDT.c STC8G_H_ADC.c
    ./Driver/isr/: STC8G_H_ADC_Isr.c STC8G_H_Timer_Isr.c
    ./Driver/inc/: Config.h STC8G_H_GPIO.h STC8G_H_NVIC.h STC8G_H_Timer.h STC8G_H_WDT.h STC8xxxx.H system_init.h Type_def.h STC8G_H_ADC.h
