# Keil uVision project si_digital_tube.uvproj, settings and files
target si_digital_tube (MCS-51)
  device: STC8G1K08 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: si_digital_tube +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\Driver\inc;.\Driver\src
  group Source Group 1
    ./: STARTUP.A51
  group src
    ./src/: led2_digital_tube.c stc8g1k_code.c uart.c infrared.c touch.c temperature.c adc.c buzzer.c encryptionDecryption.c areaFill1.c areaFill2.c
  group inc
    ./src/: global.h led2_digital_tube.h stc8g1k_code.h uart.h infrared.h touch.h temperature.h adc.h buzzer.h encryptionDecryption.h
  group driver
    ./Driver/src/: STC8G_H_ADC.c STC8G_H_GPIO.c
    ./Driver/inc/: Config.h STC8G_H_ADC.h STC8G_H_GPIO.h Type_def.h STC8xxxx.H
